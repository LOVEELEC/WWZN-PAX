# Keil uVision project Project.uvproj, settings and files
target MIPIFunctionTestPrj (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: VTT024QVB_LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\User;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\User\TimeOut\inc;..\..\User\DCMI_Interface\inc;..\..\User\ImageSensorDriver\inc;..\..\SimulationI2C_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group User
    ../../User/: main.c ST7789V.c systick.c fonts.c picture.c dwc_mipi_csi.c mipi_dcmi_GC2355.c mhscpu_it.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_dma.c
  group CameraConfig
    ../../User/ImageSensorDriver/src/: OV7251_MIPI_Driver.c Sensor_SCCB.C
    ../../User/DCMI_Interface/src/: DCMI_Interface.c
    ../../SimulationI2C_lib/src/: simulation_i2c.c si2c_delay.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group TimeOut
    ../../User/TimeOut/src/: timeOut.c
  group readme
    ../../User/: readme.txt
